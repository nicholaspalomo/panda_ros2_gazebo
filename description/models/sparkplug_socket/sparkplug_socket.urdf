Commit message: spawn the sparkplug socket in Gazebo for pick and insert example

File: description/models/sparkplug_socket/sparkplug_socket.urdf (robot description, URDF)
Before this commit: robot sparkplug_socket, 1 links, 1 joints
Joints:
- removed joint fixed_to_world
